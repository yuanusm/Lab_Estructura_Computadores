<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Estructuras_Configurado_Manualmente.ewp</path>
  </project>
  <batchBuild />
</workspace>
